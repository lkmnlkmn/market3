# Keil uVision project APP.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: APP +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: ..\Api;..\User
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Api
    ../Api/: startup_stm32f10x_md.s Api_System.c
  group User
    ../User/: App.c main.c
software components: CMSIS:CORE 5.1.2
