# Keil uVision project APP.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: APP +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: ..\Api;..\User
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Api
    ../Api/: startup_stm32f10x_md.s Api_System.c
  group User
    ../User/: App.c main.c
